require recipes-security/optee-adi/include/optee-apps-userspace-adi.inc
require recipes-security/optee-adi/include/optee-revs-adi_git.inc

SRCREV = "${OPTEE_APPS_SRCREV}"
