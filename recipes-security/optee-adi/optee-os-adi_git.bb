require recipes-security/optee-adi/include/optee-os-adi.inc
require recipes-security/optee-adi/include/optee-revs-adi_git.inc

SRCREV = "${OPTEE_OS_SRCREV}"
