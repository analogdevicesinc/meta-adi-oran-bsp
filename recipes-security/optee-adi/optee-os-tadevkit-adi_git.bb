require include/optee-os-tadevkit-adi.inc
require include/optee-revs-adi_git.inc

SRCREV = "${OPTEE_OS_SRCREV}"
