#adrv904x is fetching Intel's etile ethernet driver from v5.15.100

LINUX_VERSION = '5.15.100'
SRCREV = '804b84a70ae3e211f462652e8b62e7e1fd5cb829'

KCONF_MODE = "allnoconfig"
unset KBUILD_DEFCONFIG
